# Keil uVision project SingleSidedTWR.uvprojx, settings and files
target USBSystem-AP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411C
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F411xE, ARM_MATH_CM4, __FPU_PRESENT = 1,_DEV_NROLE_AP
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program;..\;..\Program\decadriver;..\Program\lowlayer;..\Program\network\inc;..\Program\drivers;..\Program\segger\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Program
    ../Program/: main.c ranging.c
  group Network
    ../Program/network/src/protocol/: uRegister.c uStateMaintenance.c uPTRanging.c
    ../Program/network/src/service/: uIdle.c uSVManager.c uSVShell.c
    ../Program/network/src/utils/: stdplus_queue.c conversion.c stdplus_linklist.c
    ../Program/network/src/linklayer/: uLLDriver.c uLLPacket.c
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32f411xe.s system_stm32f4xx.c
  group Library
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c
    ../Program/: stm32f4xx_conf.h
  group Driver
    ../Program/drivers/: stm32f4_delay.c stm32f4_usart.c stm32f4_spi.c
  group Module
    ../Program/modules/: serial.c dw1000.c
  group Algorithm
    ../Program/algorithms/: string.c
  group decadriver
    ../Program/decadriver/: deca_device.c deca_params.c
  group Lowlayer
    ../Program/lowlayer/: kdwm1000_bsp.c kdwm1000_it.c
  group Segger
    ../Program/segger/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Program/segger/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
target USBSystem-STA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: STM32F411C
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F411xE, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
